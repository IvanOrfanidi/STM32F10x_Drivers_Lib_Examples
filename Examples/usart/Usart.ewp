# IAR project Usart.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x_Drivers_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F10x_Drivers_Lib\CMSIS\CM3\CoreSupport; ..\..\STM32F10x_Drivers_Lib\inc; ..\..\lib\inc; vectors; ..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Usart.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.cpp
  group STM32F10x_Drivers_Lib
    ../../STM32F10x_Drivers_Lib/src/: uart.cpp
  group STM32F10x_StdPeriph_Lib
    ../../STM32F10x_StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System Core
    ../../STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group System Core/Startup
    ../../STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group System Core/Vectors
    vectors/: stm32f10x_it.c
