# IAR project Backup of Usart.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\STM32F10x_Drivers_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F10x_Drivers_Lib\CMSIS\CM3\CoreSupport; ..\..\STM32F10x_Drivers_Lib\inc; ..\..\lib\inc; vectors
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Usart.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.cpp
  group STM32F10x_Drivers_Lib
    ../../STM32F10x_Drivers_Lib/src/: rtc.cpp
  group System Core
    ../../STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group System Core/Startup
    ../../STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group System Core/Vectors
    vectors/: stm32f10x_it.c
